# Keil uVision project Cargo pilferage.uvproj, settings and files
target Target 1 (MCS-51)
  device: P89LV51RD2 NXP (founded by Philips)
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: Cargo pilferage +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: delay.c GPS_NMEA.c GSMSIM300.c keyboard.c LCD.c main.c ProjectMain.c serial_codes.c
